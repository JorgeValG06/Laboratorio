options:
  parameters:
    author: Jorge&Valeria
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: ModulacionPM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-6'
    stop: '60'
    value: '60'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    rangeType: int
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: CalculoPotencia_0
  id: CalculoPotencia
  parameters:
    I_vect: '1024'
  states: {}
- name: EnvolventeComplejaPMJ1B_0
  id: EnvolventeComplejaPMJ1B
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventeComplejaPMJ1B_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventeComplejaPMJ1B_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPMJ1B_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPMJ1B_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotencia_0, '0']

metadata:
  file_format: 1
