options:
  parameters:
    author: J&V
    generate_options: qt_gui
    id: modulacionPAM
    output_language: python
    title: modulacionPAM
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '10'
    stop: '1000'
    value: '50'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '10'
    stop: '1000'
    value: '50'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '10'
    stop: '1000'
    value: '50'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100*fs
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: ModuladorPAM_1
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_1
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_2
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_1, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_1, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_1_0, '0', blocks_delay_0, '0']
- [ModuladorPAM_1_1, '0', blocks_delay_2, '0']
- [ModuladorPAM_1_2, '0', blocks_delay_1, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_1, '0']
- [analog_sig_source_x_1, '0', ModuladorPAM_1_1, '0']
- [analog_sig_source_x_2, '0', ModuladorPAM_1_2, '0']
- [analog_sig_source_x_3, '0', ModuladorPAM_1_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '1']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
